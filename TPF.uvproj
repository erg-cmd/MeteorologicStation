# Keil uVision project TPF.uvproj, settings and files
target TPF (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TPF +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: CODE(0x0100 - 0xef00)
  group main
    ./: main.c
  group libreria
    ./: barrido_teclado.h inicializacion.h libreria.h main.h mdt.h lcd.h config_medicion.h envio_de_config.h fw_dht11.h manejo_serie.h adc0.h
  group para Organizar
    ./: inicializacion.c barrido_teclado.c mdt.c isr_timer0.c isr_timer2.c lcd.c isr_uart0.c tomar_muestra.c adc0.c config_medicion.c envio_de_config.c fw_dht11.c manejo_serie.c HextoAscii.c
